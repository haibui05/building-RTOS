# Keil uVision project stm32f10x_register.uvprojx, settings and files
target kernel (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f10x_register
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\include;..\source;..\bsp
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group source
    ../source/: main.c stm32f1xx_rcc.c stm32f1xx_gpio.c stm32f1xx_usart.c stm32f1xx_tim.c stm32f1xx_systick.c stm32f1xx_dwt.c
  group include
    ../include/: main.h stm32f1xx_rcc.h stm32f1xx_gpio.h stm32f1xx_usart.h stm32f1xx_tim.h stm32f1xx_systick.h stm32f1xx_dwt.h
  group bsp
    ../bsp/: led.c led.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
