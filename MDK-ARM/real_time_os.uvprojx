# Keil uVision project real_time_os.uvprojx, settings and files
target stm32f1xx (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: real_time_os
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD
  c include: ..\bsp;..\include;..\kernel;..\source
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group source
    ../source/: main.c stm32f1xx_dwt.c stm32f1xx_gpio.c stm32f1xx_rcc.c stm32f1xx_systick.c stm32f1xx_tim.c stm32f1xx_usart.c stm32f1xx_interrupt.c stm32f1xx_exti.c
  group include
    ../include/: stm32f1xx_afio.h stm32f1xx_dwt.h stm32f1xx_gpio.h stm32f1xx_rcc.h stm32f1xx_system.h stm32f1xx_systick.h stm32f1xx_tim.h stm32f1xx_usart.h stm32f1xx_interrupt.h stm32f1xx_exti.h
  group bsp
    ../bsp/: led.c led.h
  group kernel
    ../kernel/: os_kernel.c os_kernel.h
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0
